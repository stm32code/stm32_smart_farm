# Keil uVision project LED.uvprojx, settings and files
target KEY (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: key +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\TASK\git;..\TASK\task;..\TASK\timer;..\NET\device;..\NET\Json;..\NET\mqtt;..\NET\onenet;..\NET\massage;..\HARDWARE\ADXL345;..\HARDWARE\KEY;..\HARDWARE\OLED-SPI;..\HARDWARE\LED;..\HARDWARE\MAX30102;..\HARDWARE\USART2;..\HARDWARE\STMFLASH;..\HARDWARE\HC_SR04;..\HARDWARE\DS18B20;..\HARDWARE\DHT11;..\HARDWARE\RC522;..\HARDWARE\RELAY
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/MAX30102/: algorithm.c heartiic.c max30102.c
    ../HARDWARE/OLED-SPI/: oled.c
    ../HARDWARE/STMFLASH/: flash.c
    ../HARDWARE/DS18B20/: ds18b20.c
    ../../../87.1.登山拐杖（WIFI）/02.NET/HARDWARE/DHT11/: dht11.c
    ../HARDWARE/RC522/: rc522.c
    ../HARDWARE/RELAY/: relay.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_flash.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_pwr.c stm32f10x_sdio.c stm32f10x_iwdg.c stm32f10x_rcc.c stm32f10x_wwdg.c stm32f10x_i2c.c stm32f10x_spi.c
  group README
    ../: README.TXT
  group NET
    ../NET/Json/: cJSON.c
    ../NET/mqtt/: MqttKit.c
    ../NET/onenet/: Net.c
    ../NET/device/: usart3.c
  group TASK
    ../TASK/git/: git.c
    ../TASK/task/: task.c
    ../TASK/timer/: timer.c
